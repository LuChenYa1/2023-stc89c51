# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h OneWire.c OneWire.h AT24C02.c AT24C02.h I2C.c I2C.h Key.c Key.h Timer0_Init.c Timer0_Init.h
