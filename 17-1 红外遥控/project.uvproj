# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h LCD1602.c LCD1602.h Int0.c Int0.h Timer0_Init.c Timer0_Init.h IR.c IR.h
