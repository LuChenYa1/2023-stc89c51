# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Matrixkey.c Matrixkey.h UART.c UART.h delay.c delay.h nixie.h nixie.c Timer0_Init.c Timer0_Init.h
