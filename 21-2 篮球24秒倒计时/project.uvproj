# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  asm define: 16
  group Source Group 1
    ./: main.c Timer0_Init.c Timer0_Init.h nixie.c nixie.h delay.c delay.h INT0_Init.c INT0_Init.h Key.c Key.h INT1_Init.c INT1_Init.h main_work.c
