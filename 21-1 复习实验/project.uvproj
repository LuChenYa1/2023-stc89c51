# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h tem.asm tem1.asm tem2.asm tem3.asm tem4.asm tem5.asm TeamWork.asm Key.c Key.h MIAN_NEW.c sort.asm
